Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-04-10T22:37:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 10 22:37:37 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{9E18EE85-85A7-4B25-8AF4-967250E4EA1E}\ifc * Database version: 5507 * Database creation date: Fri Apr 10 22:37:37 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 10 22:37:37 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 10 22:37:37 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1030FS-105 Kitchen faucet, 1030FS-105(2020):1030FS-105 Kitchen faucet:331290
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - FaucetNominalDepth: 254 mm; FaucetNominalHeight: 183.5 mm; FaucetNominalWidth: 54.2 mm; InletConnectionSize: 10 mm; Projection: 213 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 1030FS-105(2020); ConvergoRefNr: 0087-2003-0066-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for kitchen; NBSReference: 45-35-70/315; ProductInformation: Kitchen Faucet; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 07/04/2020
Type - Green Building Properties(Type) - Backflow Prevention EN1717: AA; Customs Code: 84818011; EAN Number: 6414150096310; EN Standard: EN 817; LVI Number: 6219170; VVS Number: 705896434
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/1030FS-105; Catalog Drawing URL: http://static.oras.com/catdrw/1030FS-105; Class: Single lever; Dimension Drawing URL: http://static.oras.com/dimdrw/1030FS-15; FDV Document URL: http://www.oras.com/datasheet/1030FS-105/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1030FS-105; Group: Kitchen faucets; Manufacturer: Oras; Market: INT;FIN;SWE;DNK;POL;RUS;LTU;LVA;UKR; Model: 1030FS-105 Kitchen faucet; Name_en: 1030FS-105 Kitchen faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 362 x 278 x 63; Package Weight: 2 kg; Product Datasheet: http://www.oras.com/datasheet/1030FS-15/en; Product Family: Oras Safira; Product Image URL: http://static.oras.com/image/1030FS-105; Product URL: http://static.oras.com/1030FS-105; Type Name: 1030FS-105 Kitchen faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: DZR brass;3S-Installation; Aerator: CASCADE®; Connection: Flexible inlet pipes; Connection Size: G3/8; Flow Rate At 300kPa With Flow Controller: 0.00211888 m3/s; Installation and Maintenance: http://static.oras.com/manual/1030FS-105; Installation Type: Deck mounted; Lever Handle: Lever with H+C symbol; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: 40 cartridge; Mounting Holes: 1 mounting hole; Noise Class: I (ISO 3822) Oras lab.; Spare Parts: http://static.oras.com/sp/1030FS-105; Spout Swivel Range: 120° (40° - 80°); Spout Type: Swivel spout; Temperature: Temperature limiter
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Green Building; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1030FS-105(2020); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1030FS-105; Name: 1030FS-105 Kitchen faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 53x254x184 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1030FS-105; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 1030FS-105 Kitchen faucet
Constraints - FaucetDefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0714035 m2; Volume: 0.00252936 m3
Identity Data - Mark: 5
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 1030FS-105(2020): 1030FS-105 Kitchen faucet; Family and Type: 1030FS-105(2020): 1030FS-105 Kitchen faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1030FS-105(2020): 1030FS-105 Kitchen faucet; Type Id: 1030FS-105(2020): 1030FS-105 Kitchen faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
